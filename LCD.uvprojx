# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: HAL.h HAL_NVIC.h HAL_PLL.h HAL_SysTick.h HAL_UART.h HAL_GPIO.h HAL_NVIC.c HAL_GPIO.c HAL_Timer.h HAL_Timer.c tm4c123gh6pm.h HAL_SysTick.c HAL_ADC.h HAL_PWM.h HAL_PWM.c HAL_ADC.c HAL_SPI.h HAL_SPI.c HAL_Flash.h HAL_Flash.c HAL_PLL.c Switch5Position.h Switch5Positions.c
  group New Group
    ./: main.c LCD.c LCD.h LCD_Raw.h LCD_Raw.c Strings.c Strings.h Keypad.c Keypad.h UART.c UART.h
    E:/ARM full Drivers/: std_types.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
